options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: DCF77_Receiver_OOK
    output_language: python
    title: DCF77 Receiver OOK
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 150
      default simulation: 1
    label: Gain1
    start: '1'
    step: '1'
    stop: '30'
    value: '10.5'
    widget: slider
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 290
      default simulation: 1
    gui_hint: (2,0,1,1)
    label: Gain2
    start: '1'
    step: '0.5'
    stop: '30'
    value: '25'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is provided
      each time the signal is high
    gui_hint: (0,0,1,1)
    label: upper Threshold
    start: '0'
    step: '1'
    stop: '500'
    value: '80'
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is provided
      each time the signal is high
    gui_hint: (1,0,1,1)
    label: lower Threshold
    start: '0.5'
    step: '0.1'
    stop: '50'
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '150'
    win: window.WIN_HAMMING
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      filter out low noise
      below given threshold
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      for listening to the
      DCF77-signal
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute real-valued signal
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      show the decoded
      message protocol
      (mostly with 0 and 1)
      just for local
      debugging purposes
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '150'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Amplify signal
    const: gain2
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Amplify signal
    const: gain1
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide whether
      the received signal
      is a zero or a one
    high: '125'
    init: '1'
    low: '2.5'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_DCF77
    comment: |-
      Demodulation from 77.5 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      Demodulation from 77.5 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: gr_bit_detector_DCF77
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# the DCF77 detector is initially out of sync\n_in_sync = 0\n# counted number of one samples\n_num_ones = 0\n# counted number of zero samples\n_num_zeros = 0\n\n\nclass DCF77_BitDetector_blk(gr.sync_block):\n\n    def __init__(self, sample_rate=48000, tolerance=0.02):\n        gr.sync_block.__init__(\n            self,\n            name='DCF77\\nBit Detector',\n            in_sig=[np.float32],\n            out_sig=[np.float32]\n        )\n\n        # block paramters\n        # NOTE: use decimated sample rate: samp_rate/decimation\n        self.sample_rate = sample_rate\n        self.tolerance = tolerance\n\n        # messaging port\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        # timing tolerance value, if the sampled frame is\n        # slightly shorter/longer hant the defined duration\n        self._tolerance = self.sample_rate*self.tolerance\n\n        # 0.1s of zeros for the zero-bit (100ms pause)\n        self._zero_lo = self.sample_rate*0.1 - self._tolerance\n        self._zero_hi = self.sample_rate*0.1 + self._tolerance\n\n        # 0.9s of ones for the zero-bit\n        self._zero_compl_lo = self.sample_rate*0.9 - self._tolerance\n        self._zero_compl_hi = self.sample_rate*0.9 + self._tolerance\n\n        # 0.2s of zeros for the one-bit (200ms pause)\n        self._one_lo = self.sample_rate*0.2 - self._tolerance\n        self._one_hi = self.sample_rate*0.2 + self._tolerance\n\n        # 0.8s of ones for the one-bit\n        self._one_compl_lo = self.sample_rate*0.8 - self._tolerance\n        self._one_compl_hi = self.sample_rate*0.8 + self._tolerance\n\n        # 1.9s of ones for the zero-bit at position 58 (with prolonged ones)\n        self._reinit_zero_lo = self.sample_rate*1.9 - 2*self._tolerance\n        self._reinit_zero_hi = self.sample_rate*1.9 + 2*self._tolerance\n\n        # 1.8s of ones for the one-bit at position 58 (with prolonged ones)\n        self._reinit_one_lo = self.sample_rate*1.8 - 2*self._tolerance\n        self._reinit_one_hi = self.sample_rate*1.8 + 2*self._tolerance\n\n        print(\"zero\", (self._zero_hi + self._zero_lo)/2)\n        print(\"zero_comp\", (self._zero_compl_hi + self._zero_compl_lo)/2)\n        print(\"one\", (self._one_hi + self._one_lo)/2)\n        print(\"one_comp\", (self._one_compl_hi + self._one_compl_lo)/2)\n        print(\"zero_reinit\", (self._reinit_zero_hi + self._reinit_zero_lo)/2)\n        print(\"one_reinit\", (self._reinit_one_hi + self._reinit_one_lo)/2)\n\n    def work(self, input_items, output_items):\n        inp = input_items[0]\n        out = output_items[0]\n\n        out[:] = self.extract_bits(inp)\n\n        # forward input tagged signal\n        return len(out)\n\n    def extract_bits(self, inp):\n        global _in_sync\n        global _num_ones\n        global _num_zeros\n\n        out = inp\n\n        # Process the individual (finite length) stream block\n        # currently received. The synchronization and detection process\n        # is basically modelled by a finite state. machine\n        for idx, ch in enumerate(inp):\n            # increment current counters of zeros and ones correspondingly\n            if (ch == 1):\n                _num_ones += 1\n            else:   # ch == 0\n                _num_zeros += 1\n\n            # first step of synchronization,\n            # as soon as an edge\n            # from zero to one is detected\n            if (_in_sync == 0 and ch == 0):\n                _in_sync = -1\n                _num_zeros = 1\n                _num_ones = 0\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"0 => -1 {_num_zeros}, {_num_ones}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n            # do not (yet) synchronize if there\n            # is no edge from zero to one yet\n            elif (_in_sync == 0 and ch == 1):\n                # thus keep _in_sync_ = 0\n                pass\n\n            # second step of synchronization succeeds,\n            # as soon as an edge from one to zero is\n            # detected during state -1, given that the\n            # length of zeros fits to parts of the\n            # zero/one symbols correspondingly\n            if (_in_sync == -1 and ch == 1 and\n                    ((_num_zeros > self._zero_lo and\n                      _num_zeros < self._zero_hi) or\n                     (_num_zeros > self._one_lo and\n                      _num_zeros < self._one_hi))):\n                _in_sync = -2\n                _num_zeros = 0\n                _num_ones = 1\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"-1 => -2  {_num_zeros}, {_num_ones}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n            # second step of synchronization fails otherwise\n            elif (_in_sync == -1 and ch == 1 and\n                    (_num_zeros < self._zero_lo or\n                     _num_zeros > self._one_hi)):\n                _in_sync = 0\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"ERR: -1 => 0: {_num_zeros}, {_num_ones}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n                _num_zeros = 0\n                _num_ones = 1\n\n            # do not (yet) synchronize if there\n            # is no edge from zero to one yet\n            elif (_in_sync == -1 and ch == 0):\n                pass\n\n            # third (and last) step of synchronization succeeds,\n            # as soon as an edge from one to zero is\n            # detected during state -2, given that the\n            # length of ones fits to parts of the\n            # zero/one symbols correspondingly\n            if (_in_sync == -2 and ch == 0 and\n                    ((_num_ones > self._zero_compl_lo and\n                      _num_ones < self._zero_compl_hi) or\n                     (_num_ones > self._one_compl_lo and\n                      _num_ones < self._one_compl_hi))):\n                _in_sync = 1\n                _num_zeros = 1\n                _num_ones = 0\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(\"-2 => 1\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n            # third (and last) step of synchronization fails otherwise\n            elif (_in_sync == -2 and ch == 0 and\n                    ((_num_ones < self._zero_compl_lo or\n                      _num_ones > self._one_compl_hi) or\n                     (_num_ones > self._zero_compl_hi and\n                      _num_ones < self._one_compl_lo))):\n                _in_sync = -1\n                _num_zeros = 1\n                _num_ones = 0\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"ERR: -2 => -1: {_num_zeros}, {_num_ones}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n            # do not (yet) synchronize if there\n            # is no edge from one to zero yet\n            elif (_in_sync == -2 and ch == 1):\n                pass\n\n            # sync on rising edge is successful\n            # so far it is either a zero or a one symbol\n            if (_in_sync == 1 and ch == 1 and\n                    ((_num_zeros > self._zero_lo and\n                      _num_zeros < self._zero_hi) or\n                     (_num_zeros > self._one_lo and\n                      _num_zeros < self._one_hi))):\n                _in_sync = 2\n                _num_ones = 1\n\n                key = pmt.intern(\"\")\n                value = pmt.intern(f\"1 => 2 {_num_zeros}, {_num_ones}\")\n                self.add_item_tag(0,\n                                  self.nitems_written(0) + idx,\n                                  key,\n                                  value)\n\n            # detect zero bit on falling edge at each end of the symbol frame\n            if (_in_sync == 2 and ch == 0):\n\n                # detect a zero bit, if approx 0.1sec zeros and 0.9sec ones\n                # (in that order) with slight tolerances are detected\n                if (_num_zeros > self._zero_lo and\n                        _num_zeros < self._zero_hi and\n                        _num_ones > self._zero_compl_lo and\n                        _num_ones < self._zero_compl_hi):\n\n                    # reset counters to zero\n                    _num_ones = 0\n                    _num_zeros = 1\n\n                    _in_sync = 1\n\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(\"2 => 1: BIT ZERO\")\n                    self.add_item_tag(0,\n                                      self.nitems_written(0) + idx,\n                                      key,\n                                      value)\n\n                    # detected 0 bit\n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(\"0\"))\n\n                # detect a one bit, if approx 0.2sec zeros and 0.8sec ones\n                # (in that order) with slight tolerances are detected\n                elif (_num_zeros > self._one_lo and\n                      _num_zeros < self._one_hi and\n                      _num_ones > self._one_compl_lo and\n                      _num_ones < self._one_compl_hi):\n\n                    # reset counters to zero\n                    _num_ones = 0\n                    _num_zeros = 1\n\n                    _in_sync = 1\n\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(\"2 => 1: BIT ONE\")\n                    self.add_item_tag(0,\n                                      self.nitems_written(0) + idx,\n                                      key,\n                                      value)\n\n                    # detected 0 bit \n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(\"1\"))\n\n                # detect a zero bit and a new minute, if approx 0.1sec\n                # zeros and 1.9sec ones (in that order) with slight\n                # tolerances are detected\n                elif (_num_zeros > self._zero_lo and\n                      _num_zeros < self._zero_hi and\n                      _num_ones > self._reinit_zero_lo and\n                      _num_ones < self._reinit_zero_hi):\n\n                    # detected 0 bit\n                    msg = \"0\"\n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(msg))\n\n                    # detected new minute\n                    msg = \"2\"\n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(msg))\n                    # reset counters to zero\n                    _num_ones = 0\n                    _num_zeros = 1\n\n                    _in_sync = 1\n\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(\"2 => 1: NEW MIN\")\n                    self.add_item_tag(0,\n                                      self.nitems_written(0) + idx,\n                                      key,\n                                      value)\n\n                # detect a one bit and a new minute, if approx 0.2sec\n                # zeros and 1.8sec ones (in that order) with slight\n                # tolerances are detected\n                elif (_num_zeros > self._one_lo and\n                      _num_zeros < self._one_hi and\n                      _num_ones > self._reinit_one_lo and\n                      _num_ones < self._reinit_one_hi):\n\n                    # detected one bit\n                    msg = \"1\"\n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(msg))\n\n                    # detected new minute\n                    msg = \"2\"\n                    self.message_port_pub(pmt.intern(\"msg_out\"),\n                                          pmt.intern(msg))\n\n                    # reset counters to zero\n                    _num_ones = 0\n                    _num_zeros = 1\n\n                    _in_sync = 1\n\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(\"2 => 1: NEW MIN\")\n                    self.add_item_tag(0,\n                                      self.nitems_written(0) + idx,\n                                      key,\n                                      value)\n\n            elif (_in_sync == 2 and ch == 1):\n                pass\n\n        # detect and treat the case when sync is apparently lost\n        # and the counters start to overload\n        if (_num_zeros > self._one_hi*2 or\n                _num_zeros > self._reinit_one_hi*2):\n            msg = \"ERROR\"\n            self.message_port_pub(pmt.intern(\"msg_out\"),\n                                  pmt.intern(f\"({msg}), zeros:\"\n                                             f\"{_num_zeros},\"\n                                             f\" ones: {_num_ones}\"))\n\n            # trigger a re-sync\n            _in_sync = 0\n\n            # reset all counters to zero\n            _num_ones = 0\n            _num_zeros = 1\n\n            key = pmt.intern(\"\")\n            value = pmt.intern(\"2 => -1: ERROR\")\n            self.add_item_tag(0,\n                              self.nitems_written(0) + idx,\n                              key,\n                              value)\n\n        # return (float) signal block\n        return out\n"
    comment: |-
      syncs to falling edge
      * decodes 0, 0.1sec zero and 0.9sec one
      * decodes 1, 0.2sec zero and 0.8sec one
      * decodes new minute if 1,8 or 1,9sec one
    sample_rate: int(samp_rate/decimation)
    tolerance: '0.02'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Windows needs the import of zmq
    imports: import zmq
  states: {}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      This block takes the DCF77
      signal from a simulated
      Channel at 77.5 kHz.
      (both amplitude and phase
      modulated)
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      DCF77 signal
    freq0: freq_DCF77
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"unfiltered received signal frequency"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"filtered complex passband signal frequency"'
    type: complex
    ymin: '-180'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      view the noisy input signal
      to set the thresholds properly
    gui_hint: (3,0,1,1)
    label1: ''
    size: samp_rate*5
    srate: samp_rate
    type: float
    update_time: '0.025'
    ymax: hi_thres + 80
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Check if the output bitstream
      is tagged properly at the edges
    gui_hint: (4,0,1,1)
    name: decoded_DCF77_bits
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: received complex passband signal
    size: samp_rate*4
    srate: samp_rate
    type: complex
    update_time: '0.025'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Apply downsampling to
      reduce computations on
      total number of samples
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      for correct timing-display
      the previous down-sampled/decimated
      signal must be upsampled/interpolated again
    decim: '1'
    interp: decimation
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ-server
      to further decode the bits
      to human-readible
      date & time information
    timeout: '500'
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_2, '0']
- [analog_simple_squelch_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', analog_simple_squelch_cc_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', virtual_sink_0, '0']
- [blocks_threshold_ff_0, '0', gr_bit_detector_DCF77, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [gr_bit_detector_DCF77, '0', qtgui_time_sink_x_1, '0']
- [gr_bit_detector_DCF77, msg_out, blocks_message_debug_0, print]
- [gr_bit_detector_DCF77, msg_out, zeromq_push_msg_sink_1, in]
- [network_tcp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
