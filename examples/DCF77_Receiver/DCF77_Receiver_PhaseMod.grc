options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: DCF77_Receiver_PhaseMod
    output_language: python
    title: DCF77 Receiver Phase Modulation
  states: {}

blocks:
- name: chip_size
  id: variable_qtgui_range
  parameters:
    comment: |-
      NOTE:
      depends on decimation!
    label: Chip size
    rangeType: int
    start: '5'
    step: '1'
    stop: '35'
    value: '9'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '32'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 150
      default simulation: 1
    label: Gain1
    start: '10'
    step: '1'
    stop: '300'
    value: '100'
    widget: slider
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 290
      default simulation: 1
    gui_hint: (2,0,1,1)
    label: Gain2
    start: '250'
    step: '10'
    stop: '450'
    value: '350'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is provided
      each time the signal is high
    gui_hint: (0,0,1,1)
    label: upper Threshold
    start: '0'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the lower threshold
      so that the one value is provided
      each time the signal is low
    gui_hint: (1,0,1,1)
    label: lower Threshold
    start: '0.5'
    step: '0.1'
    stop: '50'
    value: '15'
  states: {}
- name: pll_bw
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '15'
    value: '5'
  states: {}
- name: pll_limit
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: thres
  id: variable_qtgui_range
  parameters:
    start: '0.1'
    step: '0.05'
    stop: '2.0'
    value: '1.0'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '150'
    win: window.WIN_BLACKMAN
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    comment: phase drift compensation
    max_freq: 2*math.pi*pll_limit/samp_rate
    min_freq: '-2*math.pi*pll_limit/samp_rate'
    w: 2*math.pi*pll_bw/samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      for listening to the
      DCF77-signal
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      down-shift signal
      to zero as central
      phase value
    const: '-0.5'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    comment: no function intended
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    comment: |-
      this extracts the phase
      modulated part (PRPSK)
      of the DCF77 signal
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute real-valued signal
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '100'
    scale: 1/5
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: normalize signal
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: gain2
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    comment: scale to be visible
    const: '200'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: '5.0'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_1
  id: blocks_multiply_const_xx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: |-
      mute signal if
      carrier is off
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide whether
      the received OOK
      signal is low
      or high
    high: '125'
    init: '1'
    low: '15'
  states: {}
- name: blocks_threshold_ff_2
  id: blocks_threshold_ff
  parameters:
    comment: |-
      detect +1 and -1
      within phase signal
    high: thres
    init: '0'
    low: '-thres'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\n# counted number of +1 samples\n_num_pos = 0\n# counted number of -1 samples\n_num_neg = 0\n\n# counter and trigger for minute marker\n_num_minmarker = 0\n_trigger_minmarker = False\n \n# array for each chip symbol per second\n_code = []\n_code = np.array(_code)\n\n\nclass DCF77_BitDetector_blk(gr.sync_block):\n\n    def __init__(self, sample_rate=48000, chip_size=75, debug=True):\n\n        gr.sync_block.__init__(\n            self,\n            name='DCF77\\nPhase Detector',\n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n\n        self.sample_rate = sample_rate\n        self.off_duration = int(self.sample_rate*0.1)\n        self.duration_pause = int(self.off_duration*0.99)\n        self.duration_minute = int(self.sample_rate*1.79)\n\n        # from signal inspection: size between approx. TBD seems good\n        self.chip_size = chip_size\n\n        # to enable/disable tags in signal\n        self.debug = debug\n\t    \n        self.message_port_register_out(pmt.intern('msg_out'))\n\n        print(\"Edge Tagger\")\n        print(\"sample_rate:\", self.sample_rate)\n        print(\"off_duration:\", self.off_duration)\n\n    def work(self, input_items, output_items):\n        inp_magn = input_items[0]\n        inp_phase = input_items[1]\n        out = output_items[0]\n\n        out[:] = self.edge_detection(inp_phase, inp_magn)\n\n        return len(out)\n\n    def code_append(self, code, num, mode):\n        # estimated number of +1/-1 for given chip_size\n        # NOTE: rounding provides much better results than just int\n        _num_bits = int(round(num/self.chip_size))\n\n        if mode == +1:\n            res = np.append(code, np.ones(_num_bits))\n        elif mode == -1:\n            res = np.append(code, np.zeros(_num_bits))\n        elif mode == 2:\n            res = np.append(code, 2)\n\n        return res\n\n    def transmit_code(self, code):\n        # convert list to a sequence of bits\n        code = code.astype(int).tolist()\n        msg = \"\".join(str(x) for x in code)\n\n        self.message_port_pub(pmt.intern(\"msg_out\"),\n                              pmt.intern(f\"{msg}\"))\n\n    def reinit_code(self):\n        global _code\n        global _num_pos\n        global _num_neg\n\n        # reinitialize code vector\n        _code = []\n        _code = np.array(_code)\n\n        _num_pos = 0\n        _num_neg = 0\n\n    def edge_detection(self, inp_phase, inp_magn):\n        global _num_pos\n        global _num_neg\n        global _num_minmarker\n        global _trigger_minmarker\n        global _code\n\n        out = inp_phase\n        \n        for idx, ch in enumerate(inp_phase):\n            if (ch == +1):\n                _num_pos += 1\n            \n            elif (ch == -1):\n                _num_neg += 1\n\n            if inp_magn[idx] == 1:\n                _num_minmarker += 1\n\n            else:\n                _num_minmarker = 0\n            \n            # detect second marker\n            if (_num_pos >= self.duration_pause or\n                    _num_neg >= self.duration_pause):\n\n                if self.debug:\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(\"\")\n                    self.add_item_tag(0,\n                        self.nitems_written(0) + idx,\n                        key,\n                        value)\n\n                # append minute marker\n                if _trigger_minmarker == True:\n                    if self.debug:\n                        key = pmt.intern(\"\")\n                        value = pmt.intern(\"2\")\n                        self.add_item_tag(0,\n                            self.nitems_written(0) + idx,\n                            key,\n                            value)\n                    \n                    _code = self.code_append(code=_code, num=_num_pos, mode=2)\n                    _trigger_minmarker = False\n                    \n                self.transmit_code(code=_code)\n                self.reinit_code()\n\n            # detect edge from +1 -> -1\n            elif _num_pos > 1 and ch == -1:\n\n                if self.debug:\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(f\"-1,{_num_pos}\")\n                    self.add_item_tag(0,\n                        self.nitems_written(0) + idx,\n                        key,\n                        value)\n\n                _code = self.code_append(code=_code, num=_num_pos, mode=+1)\n\n                _num_pos = 0\n\n            # detect edge from -1 -> +1\n            elif _num_neg > 1 and ch == +1:\n\n                if self.debug:\n                    key = pmt.intern(\"\")\n                    value = pmt.intern(f\"+1,{_num_neg}\")\n                    self.add_item_tag(0,\n                        self.nitems_written(0) + idx,\n                        key,\n                        value)\n\n                _code = self.code_append(code=_code, num=_num_neg, mode=-1)\n\n                _num_neg = 0\n\n            # detect minute marker\n            if (_num_minmarker >= self.duration_minute):\n\n                _num_minmarker = 0\n                _trigger_minmarker = True\n\n        return out\n\n"
    alias: DCF77_Phase_Detector
    chip_size: chip_size
    comment: |-
      * append tags
          0, -1, +1
      * ensure 200ms are
          muted (=0) during 
          PSN off-time
    debug: 'True'
    sample_rate: int(samp_rate/decimation)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\nfrom gnuradio import gr \nimport pmt\nimport numpy as np\n\n\nclass msg_block(gr.basic_block):\n\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name=\"Code Sequence \\n Correlator\",\n            in_sig=None,\n            out_sig=None)\n \n        # prepare in and out ports for messages\n        self.message_port_register_out(pmt.intern('msg_out'))\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n        # Both sequences have 256 ones and 256 zeros\n        # the spread spectrum codewords for the symbols 1 and 0\n        # are simply bitwise negated versions of each other.\n        # LFSR generator polynomial: x^9 + x^5 + 1\n        str_known_zero_sequence = \"00000100011000010011100101010110000110\" \\\n                                  \"11110100110111001000101000010101101001\" \\\n                                  \"11111011001001001011011111100100110101\" \\\n                                  \"00110011000000011000110010100011010010\" \\\n                                  \"11111110100010110001110101100101100111\" \\\n                                  \"10001111101110100000110101101101110110\" \\\n                                  \"00001011010111110101010100000010100101\" \\\n                                  \"01111001011101110000001110011101001001\" \\\n                                  \"11101011101010001001000011001110000101\" \\\n                                  \"11101101100110100001110111100001111111\" \\\n                                  \"11000001111011111000101110011001000001\" \\\n                                  \"00101001110110100011110011111001101100\" \\\n                                  \"01010100100011100011011010101110001001\" \\\n                                  \"100010001000000001\"\n\n        # converting these string of bits to lists with integers\n        known_zero_sequence = list(map(int, str_known_zero_sequence))\n\n        self.np_knwn_zero_seq = np.array(known_zero_sequence)\n\n        # apply a simple bitwise negation of the array\n        self.np_knwn_one_seq = 1 - np.array(known_zero_sequence)\n\n        #self._min_marker = 0\n\n    def handle_msg(self, msg):\n        # message contains whole spread sequence of a received second\n        msg = pmt.to_python(msg)\n        #print(\"Message:\", msg)\n\n        recv_sequence = list(map(int, msg))\n        np_recv_seq = np.array(recv_sequence)\n\n        # extend message at front and at back to\n        # have more correlation points in the result\n        # NOTE: this seems to be helpful if some bits\n        #       are duplicated or lost\n        np_recv_seq_padded = np.insert(np_recv_seq, 0, np.zeros(10), axis=0)\n\n        \n        # append zeros before new minute symbol \"2\"\n        if np_recv_seq_padded[-1] == 2:\n            np_recv_seq_padded = np.insert(np_recv_seq_padded,\n                                           -2, np.zeros(10), axis=0)\n        \n        else: # ordinary case \n            np_recv_seq_padded = np.insert(np_recv_seq_padded,\n                                           -1, np.zeros(10), axis=0)\n\n        if len(np_recv_seq) > 0:\n            res_zero = np.correlate(np_recv_seq_padded, self.np_knwn_zero_seq)\n            res_one = np.correlate(np_recv_seq_padded, self.np_knwn_one_seq)\n            #print(res_zero)\n            #print(res_one)\n\n            # NOTE the max-norm provides good results so far\n            norm_zero = max(res_zero)\n            norm_one = max(res_one)\n            #print(\"N0: \", norm_zero)\n            #print(\"N1: \", norm_one)\n\n            # make a decision by comparing the correlation results\n            if norm_zero > norm_one:\n                self.message_port_pub(pmt.intern('msg_out'),\n                                      pmt.intern('0'))\n\n            elif norm_zero < norm_one:\n                self.message_port_pub(pmt.intern('msg_out'),\n                                      pmt.intern('1'))\n\n            # even if these norms are identical,\n            # an error message might still be useful for the decoder\n            #else:\n            #    self.message_port_pub(pmt.intern('msg_out'),\n            #                          pmt.intern('3'))\n\n            if np_recv_seq_padded[-1] == 2:\n                self.message_port_pub(pmt.intern('msg_out'),\n                                      pmt.intern('2'))\n\n            \"\"\"\n            if self._min_marker == 1:\n                self.message_port_pub(pmt.intern('msg_out'),\n                                      pmt.intern('2'))\n                # disable minute marker   \n                self._min_marker = 0\n\n            # delay minute symbol for yet a single symbol\n            if np_recv_seq[-1] == 2:\n                # enable minute marker\n                self._min_marker = 1\n            \"\"\"\n\n"
    comment: |-
      applied on each
      full chip sequence
      at each second
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_DCF77
    comment: |-
      Demodulation from 77.5 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      Demodulation from 77.5 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    comment: Windows needs the import of zmq
    imports: import zmq
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      This block takes the DCF77
      signal from a simulated
      Channel at 77.5 kHz.
      (both amplitude and phase
      modulated)
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The official codeword for symbol 0 from the code-polynomial x⁹+x⁵+1 is:
      000001000110000100111001010101100001101111010011011100100010100001010110100
      111111011001001001011011111100100110101001100110000000110001100101000110100
      101111111010001011000111010110010110011110001111101110100000110101101101110
      110000010110101111101010101000000101001010111100101110111000000111001110100
      100111101011101010001001000#01100111000010111101101100110100001110111100001
      111111110000011110111110001011100110010000010010100111011010001111001111100
      110110001010100100011100011011010101110001001100010001000000001

      The opposite codeword for symbol 1 is its bit-wise inverted version

      It has a number of:
      * 256 ones
      * 256 zeros

      Except for the first two bits and the last 2 bits, it can  be repoduced with the following python script.
      (maybe because the initial state=[0,0,0,0,0,0,0,0,0] is not permitted)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      DCF77 signal
    freq0: freq_DCF77
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"unfiltered received signal frequency"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"filtered complex passband signal frequency"'
    type: float
    ymin: '-180'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      view the noisy input signal
      to set gain and thresholds properly
    gui_hint: (3,0,1,1)
    label1: OOK Magnitude
    label2: OOK Thresholded
    nconnections: '2'
    size: int(samp_rate/decimation)*2
    srate: int(samp_rate/decimation)
    type: float
    ymax: hi_thres + 80
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: received complex passband signal
    size: samp_rate*3
    srate: samp_rate
    type: complex
    update_time: '0.025'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    color3: black
    label1: corr. Phase
    label2: Chip Sequence
    label3: magnitude
    name: Drift Corrected Phase & PNS
    nconnections: '3'
    size: int(samp_rate/decimation*2)
    srate: int(samp_rate/decimation)
    type: float
    update_time: '0.025'
    ymax: math.pi +0.5
    ymin: '-math.pi-0.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Apply downsampling to
      reduce computations on
      total number of samples
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rcv_sig
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    comment: to detector
    stream_id: phase_sig
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    comment: to detector
    stream_id: magn_sig
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rcv_sig
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: phase_sig
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: magn_sig
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ-server
      to further decode the bits
      to human-readible
      date & time information
    timeout: '500'
  states: {}

connections:
- [analog_pll_carriertracking_cc_0, '0', blocks_multiply_const_xx_0_1, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_complex_to_mag_squared_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_moving_average_xx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_xx_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_xx_0_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_xx_0_1, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_threshold_ff_2, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '0']
- [blocks_threshold_ff_0, '0', virtual_sink_1_0, '0']
- [blocks_threshold_ff_2, '0', blocks_add_const_vxx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_2_0, '1']
- [epy_block_0, msg_out, blocks_message_debug_0, print]
- [epy_block_0, msg_out, epy_block_1, msg_in]
- [epy_block_1, msg_out, blocks_message_debug_0_0, print]
- [epy_block_1, msg_out, zeromq_push_msg_sink_1, in]
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', rational_resampler_xxx_0, '0']
- [network_tcp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_const_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [virtual_source_0, '0', blocks_complex_to_arg_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_3, '0', epy_block_0, '1']
- [virtual_source_3_0, '0', epy_block_0, '0']
- [virtual_source_3_0, '0', qtgui_time_sink_x_2_0, '2']

metadata:
  file_format: 1
