options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: DCF77_Receiver
    output_language: python
    title: DCF77 Receiver
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 150
      default simulation: 1
    label: Gain1
    start: '1'
    step: '1'
    stop: '400'
    value: '150'
    widget: slider
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    comment: |-
      default real: 290
      default simulation: 1
    gui_hint: (2,0,1,1)
    label: Gain2
    start: '1'
    step: '0.5'
    stop: '450'
    value: '150'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is provided
      each time the signal is high
    gui_hint: (0,0,1,1)
    label: upper Threshold
    start: '0'
    step: '1'
    stop: '500'
    value: '125'
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the one value is provided
      each time the signal is high
    gui_hint: (1,0,1,1)
    label: lower Threshold
    start: '0.5'
    step: '0.1'
    stop: '50'
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      filter out low noise
      below given threshold
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      for listening to the
      DCF77-signal
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute real-valued signal
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      show the decoded message protocol
      (mostly with 0 and 1)
      just for local debugging purposes
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Amplify signal
    const: gain2
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide whether
      the received signal
      is a zero or a one
    high: '125'
    init: '1'
    low: '2.5'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_DCF77
    comment: |-
      Demodulation from 77.5 kHz
      down to the base band.
    decim: '1'
    samp_rate: samp_rate
    taps: variable_low_pass_filter_taps_0
    type: ccc
  states: {}
- name: gr_bit_detector_DCF77
  id: epy_block
  parameters:
    _source_code: |
      """
      Bit Detector DCF77
      """

      """
      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      # the DCF77 detector is initially out of sync
      _in_sync = 0
      # counted number of one samples
      _num_ones = 0
      # counted number of zero samples
      _num_zeros = 0


      class blk(gr.sync_block):
          """Bit Detector DCF77"""

          def __init__(self, scaling=16, sample_rate=192000, tolerance=0.02):
              gr.sync_block.__init__(
                  self,
                  name='Bit Detector DCF77',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # block paramters
              self.sample_rate = sample_rate
              self.scaling = scaling
              self.tolerance = tolerance

              # messaging port
              self.message_port_register_out(pmt.intern('msg_out'))
              
              # timing tolerance value, if the sampled frame is
              # slightly shorter/longer hant the defined duration
              self._tolerance      = self.sample_rate/self.scaling*self.tolerance
              
              # 0.1s of zeros for the zero-bit (100ms pause)
              self._zero_lo        = self.sample_rate/self.scaling*0.1 - self._tolerance
              self._zero_hi        = self.sample_rate/self.scaling*0.1 + self._tolerance
              
              # 0.9s of ones for the zero-bit
              self._zero_compl_lo  = self.sample_rate/self.scaling*0.9 - self._tolerance
              self._zero_compl_hi  = self.sample_rate/self.scaling*0.9 + self._tolerance
              
              # 0.2s of zeros for the one-bit (200ms pause)
              self._one_lo         = self.sample_rate/self.scaling*0.2 - self._tolerance
              self._one_hi         = self.sample_rate/self.scaling*0.2 + self._tolerance
              
              # 0.8s of ones for the one-bit
              self._one_compl_lo   = self.sample_rate/self.scaling*0.8 - self._tolerance
              self._one_compl_hi   = self.sample_rate/self.scaling*0.8 + self._tolerance
              
              # 1.9s of ones for the zero-bit at position 58 (with prolonged ones)
              self._reinit_zero_lo = self.sample_rate/self.scaling*1.9 - 2*self._tolerance
              self._reinit_zero_hi = self.sample_rate/self.scaling*1.9 + 2*self._tolerance
              
              # 1.8s of ones for the one-bit at position 58 (with prolonged ones)
              self._reinit_one_lo  = self.sample_rate/self.scaling*1.8 - 2*self._tolerance
              self._reinit_one_hi  = self.sample_rate/self.scaling*1.8 + 2*self._tolerance
       
              print("zero", (self._zero_hi + self._zero_lo)/2)
              print("zero_comp", (self._zero_compl_hi + self._zero_compl_lo)/2)
              print("one", (self._one_hi + self._one_lo)/2)
              print("one_comp", (self._one_compl_hi + self._one_compl_lo)/2)
              print("zero_reinit", (self._reinit_zero_hi + self._reinit_zero_lo)/2)
              print("one_reinit", (self._reinit_one_hi + self._reinit_one_lo)/2)


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              
              # the actual detector-magic happens here
              out[:] = self.extract_bits(inp)
              
              # forward input tagged signal
              return len(output_items[0])


          def extract_bits(self, inp):
              global _in_sync
              global _num_ones
              global _num_zeros
              
              out = inp
              
              # Process the individual (finite length) stream block currently received.
              # The synchronization and detection process is basically modelled by a finite state. machine
              for idx, ch in enumerate(inp):
                  # increment current counters of zeros and ones correspondingly
                  if (ch == 1):
                      _num_ones += 1
                  else: # ch == 0
                      _num_zeros += 1
                  
                  # first step of synchronization, as soon as an edge
                  # from zero to one is detected
                  if (_in_sync == 0 and ch == 0):
                      _in_sync = -1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"0 => -1 {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # do not (yet) synchronize if there
                  # is no edge from zero to one yet
                  elif (_in_sync == 0 and ch == 1):
                      pass
                  
                  # second step of synchronization succeeds,
                  # as soon as an edge from one to zero is
                  # detected during state -1, given that the
                  # length of zeros fits to parts of the
                  # zero/one symbols correspondingly
                  if (_in_sync == -1 and ch == 1 and 
                       ((_num_zeros > self._zero_lo and _num_zeros < self._zero_hi) or
                        (_num_zeros > self._one_lo  and _num_zeros < self._one_hi))):
                      _in_sync = -2
                      _num_zeros = 0
                      _num_ones = 1
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"-1 => -2  {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # second step of synchronization fails otherwise
                  elif (_in_sync == -1 and ch == 1 and
                      (_num_zeros < self._zero_lo or _num_zeros > self._one_hi)):
                      _in_sync = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"ERR: -1 => 0: {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                      _num_zeros = 0
                      _num_ones = 1
                  
                  # do not (yet) synchronize if there
                  # is no edge from zero to one yet
                  elif (_in_sync == -1 and ch == 0):
                      pass
                  
                  # third (and last) step of synchronization succeeds,
                  # as soon as an edge from one to zero is
                  # detected during state -2, given that the
                  # length of ones fits to parts of the
                  # zero/one symbols correspondingly
                  if (_in_sync == -2 and ch == 0 and 
                      ((_num_ones > self._zero_compl_lo and _num_ones < self._zero_compl_hi) or
                      (_num_ones > self._one_compl_lo and _num_ones < self._one_compl_hi))):
                      _in_sync = 1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("-2 => 1")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # third (and last) step of synchronization fails otherwise
                  elif (_in_sync == -2 and ch == 0 and
                       ((_num_ones < self._zero_compl_lo or _num_ones > self._one_compl_hi) or
                        (_num_ones > self._zero_compl_hi and _num_ones < self._one_compl_lo))):
                      _in_sync = -1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"ERR: -2 => -1: {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # do not (yet) synchronize if there
                  # is no edge from one to zero yet
                  elif  (_in_sync == -2 and ch == 1):
                      pass
                  
                  
                  # sync on rising edge is successful
                  # so far it is either a zero or a one symbol
                  if (_in_sync == 1 and ch == 1 and 
                      ((_num_zeros > self._zero_lo and _num_zeros < self._zero_hi) or
                      (_num_zeros > self._one_lo  and _num_zeros < self._one_hi))):
                      _in_sync = 2
                      _num_ones = 1
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"1 => 2 {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  
                  # detect zero bit on falling edge at each end of the symbol frame
                  if (_in_sync == 2 and ch == 0):
                  
                      # detect a zero bit, if approx 0.1sec zeros and 0.9sec ones
                      # (in that order) with slight tolerances are detected
                      if (_num_zeros > self._zero_lo and _num_zeros < self._zero_hi and
                          _num_ones > self._zero_compl_lo and _num_ones < self._zero_compl_hi):
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: BIT ZERO")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                          
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern("0"))
                      
                      # detect a one bit, if approx 0.2sec zeros and 0.8sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._one_lo and _num_zeros < self._one_hi and
                            _num_ones > self._one_compl_lo and _num_ones < self._one_compl_hi):
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: BIT ONE")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                          
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern("1"))
                      
                      # detect a zero bit and a new minute, if approx 0.1sec zeros and 1.9sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._zero_lo and _num_zeros < self._zero_hi and
                            _num_ones > self._reinit_zero_lo and _num_ones < self._reinit_zero_hi):
                          
                          msg = "new minute, 0"
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern(msg))
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: NEW MIN")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                      
                      # detect a one bit and a new minute, if approx 0.2sec zeros and 1.8sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._one_lo and _num_zeros < self._one_hi and
                            _num_ones > self._reinit_one_lo and _num_ones < self._reinit_one_hi):
                          
                          msg = "new minute, 1"
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern(msg))
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: NEW MIN")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                  
                  elif (_in_sync == 2 and ch == 1):
                      pass
              
              # detect and treat the case when sync is apparently lost and the counters start to overload
              if (_num_zeros > self._one_hi*2 or _num_zeros > self._reinit_one_hi*2):
                  msg = "ERROR"
                  self.message_port_pub(pmt.intern("msg_out"), pmt.intern(f"({msg}), zeros: {_num_zeros}, ones: {_num_ones}"))
                  
                  # trigger a re-sync
                  _in_sync = 0
                  
                  # reset all counters to zero
                  _num_ones = 0
                  _num_zeros = 1
                  
                  key = pmt.intern("edge")
                  value = pmt.intern("2 => -1: ERROR")
                  self.add_item_tag(0,
                      self.nitems_written(0) + idx,
                      key,
                      value
                  )
              
              # return (float) signal block
              return out
    comment: |-
      syncs to falling edge
      * decodes 0, 0.1sec zero and 0.9sec one
      * decodes 1, 0.2sec zero and 0.8sec one
      * decodes new minute if 1,8 or 1,9sec one
    sample_rate: samp_rate
    scaling: decimation
    tolerance: '0.02'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: windows needs the import of zmq
    imports: import zmq
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: |-
      A fairly dense filter to just
      pick up the DCF77 spike
    cutoff_freq: 0.7e3
    decim: '1'
    gain: gain1
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_KAISER
  states: {state: disabled}
- name: network_tcp_source_1
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      This block takes the DCF77
      signal from a simulated
      Channel at 77.5 kHz.
    port: '55554'
    server: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      DCF77 signal
    freq0: freq_DCF77
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"unfiltered received signal frequency"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    name: '"filtered complex passband signal frequency"'
    type: complex
    ymin: '-180'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      view the noisy input signal
      to set the thresholds properly
    gui_hint: (3,0,1,1)
    label1: ''
    size: samp_rate*5
    srate: samp_rate
    type: float
    ymax: hi_thres + 45
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Check if the output bitstream
      is tagged properly at the edges
    gui_hint: (4,0,1,1)
    name: decoded_DCF77_bits
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: received complex passband signal
    size: samp_rate*4
    srate: samp_rate
    type: complex
    ymax: '0.15'
    ymin: '-0.15'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Apply downsampling to
      reduce computations on
      total number of samples
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      for correct timing-display
      the previous down-sampled/decimated
      signal must be upsampled/interpolated again
    decim: '1'
    interp: decimation
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    comment: |-
      provide signal to a ZMQ server
      to futher decode the bits
      to human-readible
      date & time information
    timeout: '500'
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_time_sink_x_2, '0']
- [analog_simple_squelch_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_threshold_ff_0, '0', gr_bit_detector_DCF77, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [gr_bit_detector_DCF77, '0', qtgui_time_sink_x_1, '0']
- [gr_bit_detector_DCF77, msg_out, blocks_message_debug_0, print]
- [gr_bit_detector_DCF77, msg_out, zeromq_push_msg_sink_1, in]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [network_tcp_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
