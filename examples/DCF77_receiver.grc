options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: DCF77 GUI
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    label: Gain1
    start: '1'
    step: '1'
    stop: '400'
    value: '150'
    widget: slider
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    gui_hint: (2,0,1,1)
    label: Gain2
    start: '1'
    step: '1'
    stop: '450'
    value: '150'
  states: {}
- name: hi_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the high value is
      provided each time the signal
      is high
    gui_hint: (0,0,1,1)
    label: upper Threshold
    start: '0'
    step: '1'
    stop: '500'
    value: '125'
  states: {}
- name: lo_thres
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adapt the upper threshold
      so that the low value is provided
      each time the signal is low
    gui_hint: (1,0,1,1)
    label: lower Threshold
    start: '0.5'
    step: '0.1'
    stop: '50'
    value: '2.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    comment: |-
      filter out low noise
      below threshold
    threshold: '-50'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Compute real-valued signal
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    comment: |-
      show the decoded message protocol
      (mostly with 0 and 1)
      just for local debugging purposes
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Amplify signal
    const: gain2
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: |-
      Decide if received
      value is low=> zero
      or high => one
    high: hi_thres
    init: '1'
    low: lo_thres
  states: {}
- name: gr_bit_detector_DCF77
  id: epy_block
  parameters:
    _source_code: |
      """
      Decode DCF77
      """

      """
      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt



      # the DCF77 detector is initially out of sync
      _in_sync = 0
      # counted number of one samples
      _num_ones = 0
      # counted number of zero samples
      _num_zeros = 0


      class blk(gr.sync_block):
          """DCF77 Bit Detector"""

          def __init__(self, scaling=16, sample_rate=192000, tolerance=0.02):
              gr.sync_block.__init__(
                  self,
                  name='DCF77 Bit Detector',
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )

              # block paramters
              self.sample_rate = sample_rate
              self.scaling = scaling
              self.tolerance = tolerance

              # messaging port
              self.message_port_register_out(pmt.intern('msg_out'))
              
              # timing tolerance value, if the sampled frame is
              # slightly shorter/longer hant the defined duration
              self._tolerance      = self.sample_rate/self.scaling*self.tolerance
              
              # 0.1s of zeros for the zero-bit (100ms pause)
              self._zero_lo        = self.sample_rate/self.scaling*0.1 - self._tolerance
              self._zero_hi        = self.sample_rate/self.scaling*0.1 + self._tolerance
              
              # 0.9s of ones for the zero-bit
              self._zero_compl_lo  = self.sample_rate/self.scaling*0.9 - self._tolerance
              self._zero_compl_hi  = self.sample_rate/self.scaling*0.9 + self._tolerance
              
              # 0.2s of zeros for the one-bit (200ms pause)
              self._one_lo         = self.sample_rate/self.scaling*0.2 - self._tolerance
              self._one_hi         = self.sample_rate/self.scaling*0.2 + self._tolerance
              
              # 0.8s of ones for the one-bit
              self._one_compl_lo   = self.sample_rate/self.scaling*0.8 - self._tolerance
              self._one_compl_hi   = self.sample_rate/self.scaling*0.8 + self._tolerance
              
              # 1.9s of ones for the zero-bit at position 58 (with prolonged ones)
              self._reinit_zero_lo = self.sample_rate/self.scaling*1.9 - 2*self._tolerance
              self._reinit_zero_hi = self.sample_rate/self.scaling*1.9 + 2*self._tolerance
              
              # 1.8s of ones for the one-bit at position 58 (with prolonged ones)
              self._reinit_one_lo  = self.sample_rate/self.scaling*1.8 - 2*self._tolerance
              self._reinit_one_hi  = self.sample_rate/self.scaling*1.8 + 2*self._tolerance
       
              print((self._zero_hi + self._zero_lo)/2)
              print((self._zero_compl_hi + self._zero_compl_lo)/2)
              print((self._one_hi + self._one_lo)/2)
              print((self._one_compl_hi + self._one_compl_lo)/2)
              print((self._reinit_zero_hi + self._reinit_zero_lo)/2)
              print((self._reinit_one_hi + self._reinit_one_lo)/2)


          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              
              # the actual detector-magic happens here
              out[:] = self.extract_bits(inp)
              
              # forward input tagged signal
              return len(output_items[0])


          def extract_bits(self, inp):
              global _in_sync
              global _num_ones
              global _num_zeros
              
              out = inp
              
              # Process the individual (finite length) stream block currently received.
              # The synchronization and detection process is basically modelled by a finite state. machine
              for idx, ch in enumerate(inp):
                  # increment current counters of zeros and ones correspondingly
                  if (ch == 1):
                      _num_ones += 1
                  else: # ch == 0
                      _num_zeros += 1
                  
                  # first step of synchronization, as soon as an edge
                  # from zero to one is detected
                  if (_in_sync == 0 and ch == 0):
                      _in_sync = -1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("0 => -1")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # do not (yet) synchronize if there
                  # is no edge from zero to one yet
                  elif (_in_sync == 0 and ch == 1):
                      pass
                  
                  # second step of synchronization succeeds,
                  # as soon as an edge from one to zero is
                  # detected during state -1, given that the
                  # length of zeros fits to parts of the
                  # zero/one symbols correspondingly
                  if (_in_sync == -1 and ch == 1 and 
                       ((_num_zeros > self._zero_lo and _num_zeros < self._zero_hi) or
                        (_num_zeros > self._one_lo  and _num_zeros < self._one_hi))):
                      _in_sync = -2
                      _num_zeros = 0
                      _num_ones = 1
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("-1 => -2")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # second step of synchronization fails otherwise
                  elif (_in_sync == -1 and ch == 1 and
                      (_num_zeros < self._zero_lo or _num_zeros > self._one_hi)):
                      _in_sync = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern(f"ERR: -1 => 0: {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                      _num_zeros = 0
                      _num_ones = 1
                  
                  # do not (yet) synchronize if there
                  # is no edge from zero to one yet
                  elif (_in_sync == -1 and ch == 0):
                      pass
                  
                  # third (and last) step of synchronization succeeds,
                  # as soon as an edge from one to zero is
                  # detected during state -2, given that the
                  # length of ones fits to parts of the
                  # zero/one symbols correspondingly
                  if (_in_sync == -2 and ch == 0 and 
                      ((_num_ones > self._zero_compl_lo and _num_ones < self._zero_compl_hi) or
                      (_num_ones > self._one_compl_lo and _num_ones < self._one_compl_hi))):
                      _in_sync = 1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("-2 => 1")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # third (and last) step of synchronization fails otherwise
                  elif (_in_sync == -2 and ch == 0 and
                       ((_num_ones < self._zero_compl_lo or _num_ones > self._one_compl_hi) or
                        (_num_ones > self._zero_compl_hi and _num_ones < self._one_compl_lo))):
                      _in_sync = -1
                      _num_zeros = 1
                      _num_ones = 0
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("ERR: -2 => -1: {_num_zeros}, {_num_ones}")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  # do not (yet) synchronize if there
                  # is no edge from one to zero yet
                  elif  (_in_sync == -2 and ch == 1):
                      pass
                  
                  
                  # sync on rising edge is successful
                  # so far it is either a zero or a one symbol
                  if (_in_sync == 1 and ch == 1 and 
                      ((_num_zeros > self._zero_lo and _num_zeros < self._zero_hi) or
                      (_num_zeros > self._one_lo  and _num_zeros < self._one_hi))):
                      _in_sync = 2
                      _num_ones = 1
                      
                      key = pmt.intern("edge")
                      value = pmt.intern("1 => 2")
                      self.add_item_tag(0,
                          self.nitems_written(0) + idx,
                          key,
                          value
                      )
                  
                  
                  # detect zero bit on falling edge at each end of the symbol frame
                  if (_in_sync == 2 and ch == 0):
                  
                      # detect a zero bit, if approx 0.1sec zeros and 0.9sec ones
                      # (in that order) with slight tolerances are detected
                      if (_num_zeros > self._zero_lo and _num_zeros < self._zero_hi and
                          _num_ones > self._zero_compl_lo and _num_ones < self._zero_compl_hi):
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: BIT ZERO")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                          
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern("0"))
                      
                      # detect a one bit, if approx 0.2sec zeros and 0.8sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._one_lo and _num_zeros < self._one_hi and
                            _num_ones > self._one_compl_lo and _num_ones < self._one_compl_hi):
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: BIT ONE")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                          
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern("1"))
                      
                      # detect a zero bit and a new minute, if approx 0.1sec zeros and 1.9sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._zero_lo and _num_zeros < self._zero_hi and
                            _num_ones > self._reinit_zero_lo and _num_ones < self._reinit_zero_hi):
                          
                          msg = "new minute, 0"
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern(msg))
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: NEW MIN")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                      
                      # detect a one bit and a new minute, if approx 0.2sec zeros and 1.8sec ones
                      # (in that order) with slight tolerances are detected
                      elif (_num_zeros > self._one_lo and _num_zeros < self._one_hi and
                            _num_ones > self._reinit_one_lo and _num_ones < self._reinit_one_hi):
                          
                          msg = "new minute, 1"
                          self.message_port_pub(pmt.intern("msg_out"), pmt.intern(msg))
                          
                          # reset counters to zero
                          _num_ones = 0
                          _num_zeros = 1
                          
                          _in_sync = 1
                          
                          key = pmt.intern("edge")
                          value = pmt.intern("2 => 1: NEW MIN")
                          self.add_item_tag(0,
                              self.nitems_written(0) + idx,
                              key,
                              value
                          )
                  
                  elif (_in_sync == 2 and ch == 1):
                      pass
              
              # detect and treat the case when sync is apparently lost and the counters start to overload
              if (_num_zeros > self._one_hi*2 or _num_zeros > self._reinit_one_hi*2):
                  msg = "ERROR"
                  self.message_port_pub(pmt.intern("msg_out"), pmt.intern(f"({msg}), zeros: {_num_zeros}, ones: {_num_ones}"))
                  
                  # trigger a re-sync
                  _in_sync = 0
                  
                  # reset all counters to zero
                  _num_ones = 0
                  _num_zeros = 1
                  
                  key = pmt.intern("edge")
                  value = pmt.intern("2 => -1: ERROR")
                  self.add_item_tag(0,
                      self.nitems_written(0) + idx,
                      key,
                      value
                  )
              
              # return (float) signal block
              return out
    comment: |-
      syncs to falling edge
      * decodes 0, 0.1sec zero and 0.9sec one => bit zero
      * decodes 1, 0.2sec zero and 0.8sec one => bit one
      * decodes 'new minute' if 1,8 or 1,9sec one
    sample_rate: samp_rate
    scaling: decimation
    tolerance: '0.02'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    comment: |-
      A fairly dense filter to just
      pick up the DCF77 spike
    cutoff_freq: 1.2e3
    decim: '1'
    gain: gain1
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '250'
    win: window.WIN_KAISER
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Do not worry if the Message Debug Print shows several ERROR first...

      When running this flowchart ensure that:
      * Ensure that the general reception of the signal at 77.5 kH is good and
         distinguishable this will only work in central Europe:
        https://www.ptb.de/cms/en/ptb/fachabteilungen/abt4/fb-44/ag-442/dissemination-of-legal-time/dcf77/reach-of-dcf77.html
      * Ensure that the amplitudes for "low" and "high" of "data0"
         are sufficiently distinct (e.g. low appox. 0.5, and high approx. 100) by adjusting
         the gain2 and gain one ranges
      * Ensure that the higher threshold is set where "high" is visible
        in the "data0" chart, e.g. approx. 100
      * Ensure that the lower theshold is approx- 0.5 (zoom into "data0")
      * then you should obtain either a 1 or a 0 each second, or a "new Minute" signal
      * the signal1 should should show edges and detected bits

      to decode the received bits, run the DecodeDCF77.py script
      * since you did not start at the beginning, the first minute is usually incomplete
      * so wait until the decoder synchronized to the new minute signal
    note: INSTRUCTIONS
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspyhf=0
    bb_gain0: '0'
    bw0: '4000'
    comment: |-
      frame is localized on the
      center frequency of the
      DCF77 signal
    freq0: freq_DCF77
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '2000'
    fc: '77500'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: |-
      View downsampled and scaled input signal
      (as spectrum, waterfall, signal, symbol constellation)
    fc: '0'
    fftsize: '1024'
    gui_hint: (5,0,1,1)
    rate: '100'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      view the noisy input signal
      to set the thresholds properly
    gui_hint: (3,0,1,1)
    label1: ''
    size: samp_rate*5
    srate: samp_rate
    type: float
    ymax: hi_thres + 45
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Check if the output bitstream
      is tagged properly at the edges
    gui_hint: (4,0,1,1)
    size: '40000'
    srate: samp_rate
    type: float
    update_time: '0.01'
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Apply downsampling to
      reduce computations on
      total number of samples
    decim: decimation
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    comment: |-
      for correct timing-display
      the previous down-sampled/decimated
      signal must be upsampled/interpolated again
    decim: '1'
    interp: decimation
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '0'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: zeromq_push_msg_sink_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:55555
    timeout: '500'
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0, '0']
- [blocks_threshold_ff_0, '0', gr_bit_detector_DCF77, '0']
- [gr_bit_detector_DCF77, '0', qtgui_time_sink_x_1, '0']
- [gr_bit_detector_DCF77, msg_out, blocks_message_debug_0, print]
- [gr_bit_detector_DCF77, msg_out, zeromq_push_msg_sink_1, in]
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1, '0', blocks_threshold_ff_0, '0']

metadata:
  file_format: 1
