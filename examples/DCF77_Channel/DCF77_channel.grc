options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: DCF77_Channel
    output_language: python
    title: DCF77 Channel
  states: {}

blocks:
- name: NoiseGain
  id: variable_qtgui_range
  parameters:
    label: NoiseGain
    start: '0.0001'
    step: '0.0001'
    stop: '0.025'
    value: '0.015'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: NoiseGain
    comment: |-
      Gaussian noise is added
      to simulate a noisy channel
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    comment: |-
      signal to the
      DCF77-Receiver
    mode: '2'
    port: '55554'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    comment: |-
      signal from the simulated
      DCF77-Transmitter
    maxoutbuf: '384000'
    minoutbuf: '192000'
    port: '55553'
    server: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: DCF77 Signal on Channel, Frequency
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: DCF-Signal on Channel, Time
    size: samp_rate*4
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', network_tcp_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [network_tcp_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
