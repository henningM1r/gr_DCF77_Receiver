options:
  parameters:
    author: henningM1R
    generate_options: qt_gui
    id: DCF77_Channel
    output_language: python
    title: DCF77 Channel
  states: {}

blocks:
- name: NoiseGain
  id: variable_qtgui_range
  parameters:
    label: NoiseGain
    start: '0.01'
    step: '0.01'
    stop: '3'
    value: '1.0'
  states: {}
- name: c
  id: variable
  parameters:
    comment: speed of light
    value: 3e8
  states: {}
- name: fading_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      low frequency => slower fades
      high frequency => faster fades
    start: 1e6
    step: 0.1e6
    stop: 6e6
    value: 1.25e6
  states: {}
- name: fading_toggle_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    comment: |-
      enable/disable slow
      fading effect
    initPressed: 'False'
    label: Fading (on/off)
    pressBackgroundColor: green
    pressFontColor: black
    pressed: '1'
    relBackgroundColor: gray
    relFontColor: black
    released: '0'
    type: int
    value: '0'
  states: {}
- name: freq_DCF77
  id: variable
  parameters:
    value: '77500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: v
  id: variable
  parameters:
    comment: |-
      speed
      (faster than in reality)
    value: 1/3.6
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: NoiseGain
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: channels_fading_model_0
  id: channels_fading_model
  parameters:
    LOS: 'False'
    N: '12'
    fDTs: fading_freq * v / c / samp_rate
    seed: '0'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '55554'
    type: complex
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    maxoutbuf: '384000'
    minoutbuf: '192000'
    port: '55553'
    server: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: DCF77 Signal on Channel, Frequency
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: DCF-Signal on Channel, Time
    size: samp_rate*4
    srate: samp_rate
    type: complex
    update_time: '0.025'
    ymax: '4.5'
    ymin: '-4.5'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_selector_0_0, '0']
- [blocks_add_xx_0, '0', channels_fading_model_0, '0']
- [blocks_selector_0_0, '0', network_tcp_sink_0, '0']
- [blocks_selector_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_0, '0']
- [channels_fading_model_0, '0', blocks_selector_0_0, '1']
- [fading_toggle_button, state, blocks_selector_0_0, iindex]
- [network_tcp_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
